# Keil uVision project ds1307-lcd.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: ds1307-lcd +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: ds1307-lcd.c delay.c i2c.c DS1307.c lcd16x2.c delay.h i2c.h DS1307.h lcd16x2.h port.h
